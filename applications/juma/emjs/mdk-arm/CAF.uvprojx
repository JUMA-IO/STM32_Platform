# Keil uVision project CAF.uvprojx, settings and files
target Cannon_V2 (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAF_V2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,ENABLE_SPI_FIX,BLUENRG_MS,RTC_LSE,CANNON_V2,SENSOR_FIFO,NO_PRINTF,SERVER_ROLE
  c misc: --C99 --gnu -W#177
  c include: ..\..\echo;..\..\..\..\system\bsp\cannon_v2;..\..\..\..\system\bsp\nucleo;..\..\..\..\system\middlewares\juma;..\..\..\..\system\middlewares\juma\sdk;..\..\..\..\system\middlewares\juma\sensor;..\..\..\..\system\middlewares\juma\device_lib_Juma_Cannon;..\..\..\..\system\middlewares\juma\dispatcher;..\..\..\..\system\middlewares\juma\low_power;..\..\..\..\system\cmsis\device\st\inc;..\..\..\..\system\cmsis\include;..\..\..\..\system\drivers\juma\stm32_usb_device_library\class\HID\inc;..\..\..\..\system\drivers\juma\stm32_usb_device_library\core\inc;..\..\..\..\system\drivers\st\bluenrg\bluenrg_ms;..\..\..\..\system\middlewares\st\bluenrg_ms\inc;..\..\..\..\system\drivers\st\common;..\..\..\..\system\hal\stm32f4xx_hal_driver\inc;..\..\..\..\system\drivers\st\hts221;..\..\..\..\system\drivers\st\lps25hb;..\..\..\..\system\drivers\st\lsm303agr;..\..\..\..\system\drivers\st\lsm6ds3;..\..\..\..\system\drivers\st\lps25h
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group application/juma
    ../: app.c jsarray.c jsboolean.c jsbuiltin.c jscompile.c jsdtoa.c jsdump.c jserror.c jsfunction.c jsgc.c jsintern.c jslex.c jsmath.c jsnumber.c jsobject.c json.c jsparse.c jsproperty.c jsregexp.c jsrun.c jsstate.c jsstring.c jsvalue.c regexp.c utf.c utftype.c
  group system
    ../../../../system/: main.c
  group system/middlewares/juma
    ../../../../system/middlewares/juma/sensor/: juma_sensor.c
    ../../../../system/middlewares/juma/dispatcher/: dispatch.c
    ../../../../system/middlewares/juma/sdk/: bluenrg_sdk_api.c
    ../../../../system/middlewares/juma/low_power/: stm32f401_lp_mode.c
  group system/middlewares/st
    ../../../../system/middlewares/st/bluenrg_ms/src/: clock.c bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c gp_timer.c hci.c list.c osal.c
  group system/drivers/st
    ../../../../system/drivers/st/hts221/: hts221.c
    ../../../../system/drivers/st/lps25hb/: lps25hb.c
    ../../../../system/drivers/st/lsm6ds3/: lsm6ds3.c
    ../../../../system/drivers/st/lsm303agr/: lsm303agr.c LSM303AGR_ACC_driver.c LSM303AGR_MAG_driver.c
    ../../../../system/drivers/st/bluenrg/bluenrg_ms/: stm32_bluenrg_ble.c
    ../../../../system/drivers/st/lps25h/: lps25h.c
  group system/bsp
    ../../../../system/bsp/nucleo/: x_nucleo_iks01a1.c x_nucleo_iks01a1_hum_temp.c x_nucleo_iks01a1_imu_6axes.c x_nucleo_iks01a1_pressure.c
    ../../../../system/bsp/cannon_v2/: stm32f4xx_hal_msp.c bsp_common.c bsp_isr.c
  group system/cmiss
    ../../../../system/cmsis/device/st/src/: system_stm32f4xx.c startup_stm32f401xe.s
  group system/hal/stm32f4xx_hal_driver
    ../../../../system/hal/stm32f4xx_hal_driver/src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c
software components: CMSIS:CORE 4.1.0
