# Keil uVision project CAF.uvprojx, settings and files
target Cannon_V1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAF
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,ENABLE_SPI_FIX,BLUENRG_MS,RTC_LSE,CANNON_V1
  c misc: --C99 --gnu
  c include: ..\..\Sensor_Tag;..\..\..\..\System\BSP\CANNONV1;..\..\..\..\System\BSP\NUCLEO;..\..\..\..\System\DRIVERS\HTS221;..\..\..\..\System\DRIVERS\LPS25H;..\..\..\..\System\DRIVERS\LPS25HB;..\..\..\..\System\DRIVERS\LSM303AGR;..\..\..\..\System\DRIVERS\LSM6DS3;..\..\..\..\System\DRIVERS\STM32F4xx_HAL_Driver\Inc;..\..\..\..\System\JUMA\Inc;..\..\..\..\System\CMISS\Device\ST\Include;..\..\..\..\System\CMISS\Include;..\..\..\..\System\DRIVERS\COMMON;..\..\..\..\System\DRIVERS\BlueNRG\Inc;..\..\..\..\System\DRIVERS\BlueNRG\BlueNRG_MS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Product/Application
    ../: app.c
  group System/JUMA
    ../../../../System/JUMA/Src/: main.c bluenrg_sdk_api.c dispatch.c stm32f401_lp_mode.c bluenrg_interface.c stm32xx_it.c clock.c cube_hal_f4.c juma_sensor.c
  group System/DRIVERS
    ../../../../System/DRIVERS/HTS221/: hts221.c
    ../../../../System/DRIVERS/LPS25H/: lps25h.c
    ../../../../System/DRIVERS/LPS25HB/: lps25hb.c
    ../../../../System/DRIVERS/LSM6DS3/: lsm6ds3.c
    ../../../../System/DRIVERS/LSM303AGR/: lsm303agr.c LSM303AGR_ACC_driver.c LSM303AGR_MAG_driver.c
    ../../../../System/DRIVERS/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_usb.c
    ../../../../System/DRIVERS/BlueNRG/Src/: list.c bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_itf_template.c bluenrg_l2cap_aci.c gp_timer.c hci.c osal.c
    ../../../../System/DRIVERS/BlueNRG/BlueNRG_MS/: stm32_bluenrg_ble.c
  group System/BSP
    ../../../../System/BSP/NUCLEO/: x_nucleo_iks01a1_hum_temp.c x_nucleo_iks01a1_imu_6axes.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1.c
    ../../../../System/BSP/CANNONV1/: stm32f4xx_hal_msp.c stm32f4xx_cannon_v1.c
    ../../../../System/BSP/CANNONV2/: stm32f4xx_cannon_v2.c
  group System/CMISS
    ../../../../System/CMISS/Device/ST/Source/: startup_stm32f401xe.s system_stm32f4xx.c
target Cannon_V2 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: as above
  output: CAF_V2
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,ENABLE_SPI_FIX,BLUENRG_MS,RTC_LSE,CANNON_V2
  c misc: --C99 --gnu
  c include: ..\..\Sensor_Tag;..\..\..\..\System\BSP\CANNONV2;..\..\..\..\System\BSP\NUCLEO;..\..\..\..\System\DRIVERS\HTS221;..\..\..\..\System\DRIVERS\LPS25H;..\..\..\..\System\DRIVERS\LPS25HB;..\..\..\..\System\DRIVERS\LSM303AGR;..\..\..\..\System\DRIVERS\LSM6DS3;..\..\..\..\System\DRIVERS\STM32F4xx_HAL_Driver\Inc;..\..\..\..\System\JUMA\Inc;..\..\..\..\System\CMISS\Device\ST\Include;..\..\..\..\System\CMISS\Include;..\..\..\..\System\DRIVERS\COMMON;..\..\..\..\System\DRIVERS\BlueNRG\Inc;..\..\..\..\System\DRIVERS\BlueNRG\BlueNRG_MS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 4.1.0
